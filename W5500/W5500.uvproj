# Keil uVision project W5500.uvproj, settings and files
target W5500 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: W5500 +hex
  c flags: Optimize=8 SizeSpeed=1
  group USER
    ./: W5500.c main.c
